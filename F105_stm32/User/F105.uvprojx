# Keil uVision project F105.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F105
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Mylib;..\CMSIS;..\Mylib;..\ESP8266\ESP8266;..\Arith;..\Task;..\FreeRTOS\port\include;..\FreeRTOS\port\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c core_cm3.c system_stm32f10x.c stm32f10x_it.c FreeRTOSConfig.h
    ../Mylib/: delay.c
  group Library
    ../CMSIS/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startuo
    ./: startup_stm32f10x_cl.s
  group Algorithm
    ../Arith/: algorithmOfCRC.c pid.c
    ../Mylib/: KF.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Task
    ../Task/: chassis_task.c action_task.c PCReceiveTask.c AutoTask.c
    ./: led_task.c Data_Dispose.c
  group Hardware
    ../Mylib/: i2c_init.c can1_chassis.c usart1_wifi.c usart2_PC.c usart3_remote.c usart5_calib.c uart.c
    ../ESP8266/ESP8266/: bsp_esp8266.c bsp_esp8266_test.c Common.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
